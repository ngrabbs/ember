# Repository ngrabbs/ember (continued)

## KiCad design hardware/payload_compute/kicad/payload_compute_20261124/payload_compute_20261124.kicad_pcb (continued)

Schematic: p18_dual_can.kicad_sch, CAN A interface

Parts:
C63: 100n; C_0603_1608Metric; Tolerance +/-10% initial; Voltage 50V; MFG P/N C0603C104K5RACTU
C64: 1u; C_0603_1608Metric; Tolerance +/-10% initial; Voltage 25V; MFG P/N C0603C105K3RACTU
R51: 47k; R_0603_1608Metric; Tolerance +/-0.1% initial; MFG P/N TNPW060347K0BEEA
R52: 100k; R_0603_1608Metric; Tolerance +/-0.1% initial; MFG P/N TNPW0603100KBEEA
R53: 120 DNP; R_0603_1608Metric; Tolerance +/-0.1% initial; MFG P/N TNPW0603120RBEEA; not fitted
U22: TCAN334GDR; TI_D0008A_Prototype; MPN TCAN334GDR

Connections:
3V3_CARRIER: C63.1, C64.1, R51.1, R52.1, U22.3 (VCC); also elsewhere on the board
CAN_A_N: R53.2, U22.6 (CANL); also elsewhere on the board
CAN_A_P: R53.1, U22.7 (CANH); also elsewhere on the board
CAN_A_RX: R52.2, U22.4 (RXD); also elsewhere on the board
CAN_A_TX: R51.2, U22.1 (TXD); also elsewhere on the board
GND: C63.2, C64.2, U22.2 (GND), U22.5 (SHDN), U22.8 (STB); also elsewhere on the board

Notes on the sheet:
CAN A INTERFACE
U2701 runs from switched carrier 3.3V. STB and SHDN are grounded for normal operation.
H1.1 is CANL and H1.3 is CANH. Fit R2705 (120 ohms) only at a physical bus endpoint. Jetson native CAN uses J3301.143 (RX) and J3301.145 (TX). EPS powers PAYLOAD before Linux receives commands.

Schematic: p74_local_3v3_buck.kicad_sch, Local 3.3 V buck

Parts:
C20, C21: 10u; C_1210_3225Metric; MFG P/N C3225X7R1H106K250AC
C22: 100n; C_0603_1608Metric; MFG P/N C0603C104K5RACTU
C23, C24: 22u; C_1210_3225Metric; MFG P/N C3225X7R1C226K250AC
L1: 3.3uH; L_Coilcraft_XAL6030-XXX; MFG P/N XAL6030-332MEC
R24: 31.6k; R_0603_1608Metric; MFG P/N TNPW060331K6BEEA
R25: 10k; R_0603_1608Metric; MFG P/N TNPW060310K0BEEA
U8: AP62300WU-7; TSOT-23-6; MFG P/N AP62300WU-7

Connections:
3V3_AON: C23.1, C24.1, L1.2, R24.1; also elsewhere on the board
GND: C20.2, C21.2, C23.2, C24.2, R25.2, U8.1 (GND); also elsewhere on the board
MAIN_STACK_IN_POS: C20.1, C21.1, U8.3 (IN); also elsewhere on the board
unnamed: C22.2, U8.6 (BST)
unnamed: R24.2, R25.1, U8.4 (FB)
unnamed: C22.1, L1.1, U8.2 (SW)

Notes on the sheet:
Local 3.3 V supply from EPS-switched VBAT

Schematic: p63_wifi_permission_isolation.kicad_sch, WiFi permission isolation

Parts:
C65: 100n; C_0402_1005Metric; Tolerance +/-10% initial; Voltage 10V; MFG P/N C0402C104K8RACTU
U23: TMUX1511PWR; TSSOP-14_4.4x5mm_P0.65mm; MPN TMUX1511PWR

Connections:
3V3_AON: C65.1, U23.14 (VDD); also elsewhere on the board
3V3_CARRIER: U23.2 (S1); also elsewhere on the board
CARRIER_IO_PERMISSION_AON: U23.1 (SEL1), U23.4 (SEL2), U23.10 (SEL3), U23.13 (SEL4); also elsewhere on the board
GND: C65.2, U23.7 (GND); also elsewhere on the board
M2E_CLKREQ_N: U23.8 (D3); also elsewhere on the board
M2E_PERST_N: U23.6 (D2); also elsewhere on the board
M2E_WAKE_N: U23.11 (D4); also elsewhere on the board
PCIE0_CLKREQ_RAW_N: U23.9 (S3); also elsewhere on the board
PCIE0_RESET_RAW_N: U23.5 (S2); also elsewhere on the board
PCIE0_WAKE_RAW_N: U23.12 (S4); also elsewhere on the board
WIFI_LOAD_ON: U23.3 (D1); also elsewhere on the board

Board: 6 copper layers, 160 parts (0 on the bottom side), 105 nets, no tracks yet.

Other parts of the board:
MH1, MH2, MH3, MH4: MountingHole_3.18mm_Plated_6.35mmPad
MH5, MH6: MountingHole_2.7mm_M2.5
MH7: MountingHole_2.2mm_M2
